# Keil uVision project BearPi_LiteOS.uvprojx, settings and files
target BearPi_LiteOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: BearPi_LiteOS_ESP8266 +hex
  c flags: OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L431xx
  c misc: --diag_suppress=111
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\Middlewares\LiteOS\ARCH\arm\arm-m\include;..\Middlewares\LiteOS\Config;..\Middlewares\LiteOS\Kernel\include;..\Middlewares\LiteOS\Kernel\base\include;..\Middlewares\LiteOS\Kernel\extended\include;..\Middlewares\LiteOS\CMSIS\cmsis;..\Hardware\LCD;..\Middlewares\LVGL\APP;..\Middlewares\LVGL\LVGL\lvgl_port;..\Middlewares\LVGL\LVGL\lvgl\src;..\Middlewares\LVGL\APP\demo;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;..\Middlewares\MQTT\src;..\Middlewares\MQTT;..\Hardware\ESP;..\Middlewares\MQTT\app;..\Middlewares\HMAC;..\Hardware\SHT30
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c usart.c sdmmc.c spi.c stm32l4xx_it.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group LiteOS/Config
    ../Middlewares/LiteOS/Config/: los_builddef.h los_printf.h target_config.h
  group LiteOS/kernel
    ../Middlewares/LiteOS/Kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../Middlewares/LiteOS/Kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../Middlewares/LiteOS/Kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../Middlewares/LiteOS/Kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
    ../Middlewares/LiteOS/Kernel/base/mem/membox/: los_membox.c
    ../Middlewares/LiteOS/Kernel/base/misc/: los_misc.c
    ../Middlewares/LiteOS/Kernel/base/om/: los_err.c
    ../Middlewares/LiteOS/Kernel/extended/tickless/: los_tickless.c
    ../Middlewares/LiteOS/Kernel/: los_init.c
  group LiteOS/cmsis
    ../Middlewares/LiteOS/CMSIS/cmsis/: cmsis_liteos.c
  group LiteOS/arch
    ../Middlewares/LiteOS/ARCH/arm/arm-m/cortex-m4/keil/: los_dispatch_keil.S
    ../Middlewares/LiteOS/ARCH/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group Hardware
    ../Hardware/LCD/: lcd.c lcd.h
    ../Hardware/ESP/: esp8266.c
    ../Hardware/SHT30/: sht30.c sht30.h
  group LVGL/src
    ../Middlewares/LVGL/LVGL/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../Middlewares/LVGL/LVGL/lvgl/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Middlewares/LVGL/LVGL/lvgl/src/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Middlewares/LVGL/LVGL/lvgl/src/lv_gpu/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_vglite.c lv_gpu_stm32_dma2d.c
    ../Middlewares/LVGL/LVGL/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Middlewares/LVGL/LVGL/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Middlewares/LVGL/LVGL/lvgl/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
    ../Middlewares/LVGL/LVGL/lvgl/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
  group LVGL/config
    ../Middlewares/LVGL/LVGL/: lv_conf.h
  group LVGL/app
    ../Middlewares/LVGL/APP/: my_font.c
  group LVGL/port
    ../Middlewares/LVGL/LVGL/lvgl_port/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group Middlewares/MQTT/app
    ../Middlewares/MQTT/app/: huawei.c huawei.h
  group Middlewares/MQTT/port
    ../Middlewares/MQTT/: transport.c
  group Middlewares/MQTT/src
    ../Middlewares/MQTT/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Middlewares/HMAC
    ../Middlewares/HMAC/: utils_hmac.c utils_md5.c utils_sha1.c
software components: CMSIS:CORE 4.3.0
